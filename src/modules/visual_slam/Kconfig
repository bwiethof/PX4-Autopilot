## src/modules/visual_slam/Kconfig
```kconfig
menuconfig MODULES_VISUAL_SLAM
    bool "visual_slam"
    default y
    ---help---
        Enable Visual SLAM Module
```
